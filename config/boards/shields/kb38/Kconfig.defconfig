## config/boards/shields/kb38/Kconfig.defconfig
```kconfig
if SHIELD_KB38

config ZMK_KEYBOARD_NAME
    default "KB38-Cirque"

config ZMK_POINTING
    default y

endif # SHIELD_KB38
```
